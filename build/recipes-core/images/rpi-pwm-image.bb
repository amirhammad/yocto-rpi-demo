include custom-image-base.inc

IMAGE_INSTALL += " \
	pi-blaster \
	throttle2pwm \
	"
