include custom-image-base.inc

IMAGE_INSTALL += " \
	alsa-tools \
	alsa-utils \
	gstreamer1.0-omx \
	gstreamer1.0-plugins-base \
	gstreamer1.0-plugins-good \
	gstreamer1.0-plugins-bad \
	gstreamer1.0-plugins-ugly \
	"
